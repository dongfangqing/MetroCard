# Keil uVision project MealCard.uvprojx, settings and files
target MealCarl_Project (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MealCard +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Lib\CMSIS;..\Lib\CMSIS\CoreSupport;..\Lib\Libaries\inc;..\User;..\User\BEEP_Diver;..\User\LED_Driver;..\User\SysTick_Driver;..\User\Uart_Driver;..\User\RFID_SPI;..\User\RC522;..\User\key_driver;..\User\ESP_12Driver;..\User\ST_string
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Lib
    ../Lib/Libaries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Core
    ../Lib/CMSIS/CoreSupport/: core_cm3.c
    ../Lib/CMSIS/startup/arm/: startup_stm32f10x_hd.s
    ../Lib/CMSIS/: system_stm32f10x.c
  group User
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../User/key_driver/: Key_Driver.c
  group Peripheral
    ../User/BEEP_Diver/: Beep_Driver.c
    ../User/LED_Driver/: Led_Driver.c
    ../User/SysTick_Driver/: SysTick_Driver.c
    ../User/Uart_Driver/: Uart_Driver.c
    ../User/RC522/: rc522_driver.c
    ../User/RFID_SPI/: spi.c
    ../User/ESP_12Driver/: Esp_Ap.c
  group Readme
    ../Readme/: Readme.txt
